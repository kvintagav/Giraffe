# Keil uVision project LAZER.uvprojx, settings and files
target stm32f4_wiznet (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LAZER
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, DEBUG
  c include: .\Header;.\Header\W5200;.\STM32f4xx_StdPeriphDriver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SourceUser
    ./Source/: console.c eeprom.c fsmc_fpga.c main.c stm32f4xx_it.c user.c motor.c
  group SourceW5200
    ./Source/W5200/: loopback.c socket.c SPI2.c util.c w5200.c
  group LipPeriphery
    ./STM32f4xx_StdPeriphDriver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_tim.c stm32f4xx_syscfg.c
  group ::Device
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.3.1
