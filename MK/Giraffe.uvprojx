# Keil uVision project Giraffe.uvprojx, settings and files
target STM32f4 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Giraffe
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, DEBUG,DISCOVERY
  c include: .\Header;.\Header\freertos;.\Header\W5200;.\RTE\Device\STM32F407VG;.\STM32f4xx_StdPeriphDriver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source User
    ./Source/: console.c fsmc_fpga.c eeprom.c system_stm32f4xx.c
    ./Source/user_rtos/: main.c stm32f4xx_it.c user_tasks.c
  group Sourse W5200
    ./Source/W5200/: loopback.c md5.c socket.c SPI2.c util.c w5200.c
  group Sourece FreeRTOS
    ./Source/freertos/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group Lib_Periphery
    ./STM32f4xx_StdPeriphDriver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group StartUp
    ./Source/: startup_stm32f40_41xxx.s
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.1.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:DSP 1.4.1
